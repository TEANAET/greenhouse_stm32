# Keil uVision project Esp8266_Mqtt.uvprojx, settings and files
target 工程 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 工程文件 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\USER;..\HARDWARE\inc;..\CORE;..\STLIB\inc;..\HMAC\inc;..\SYS;..\HARDWARE\scr\MQ_Sensor;..\HARDWARE\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c
  group HARDWARE
    ../HARDWARE/src/: ds18b20.c control.c delay.c led.c mqtt.c stm32f10x_it.c timer2.c timer3.c timer4.c usart1.c usart2.c wifi.c system.c dht11.c usart3.c timer5.c lsens.c adc.c beep.c relay.c stmflash.c oled.c
    ../HARDWARE/src/MQ_Sensor/: MQ-Sensor.c
  group CORE
    ../CORE/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group STLIB
    ../STLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_dac.c stm32f10x_adc.c stm32f10x_flash.c
  group SYS
    ../SYS/: sys.c
    ./: json.c
